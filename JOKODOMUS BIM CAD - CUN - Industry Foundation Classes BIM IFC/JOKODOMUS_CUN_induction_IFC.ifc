Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Kitchen_Furniture_Jokodomus_CUN-Induction.ifc
Time: 2020-04-20T13:16:26
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: CUN - Induction
ePset_BIMobjectScript - Type: CUN module induction - 692x604 h950mm - 1 drawer - stainless steel - code679141 - outdoor; Wheels: Yes (standard); LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): CUN - Induction; SKU (BO_prodsku): cun-Induction; ManufacturName (BO_Manufac): Jokodomus; BrandUrl (BO_brandurl): https://www.jokodomus.com/en/; ProductFamily (BO_prodfam): Kitchen; ProductGroup (BO_prodgroup): Induction; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/jokodomus/product/cun-Induction; ProductDataUrl (BO_prodaturl): bimobject.com/jokodomus/product/cun-Induction; ProductUrl (BO_producturl): https://www.jokodomus.com/en/s/2/c/16/induction/679141; TechnicalDescription (BO_techcert): https://www.jokodomus.com/en/s/2/c/16/induction/679141; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=_zWXf_fHcQM; MaterialMain (BO_mainmat): Stainless steel; MaterialSecondary (BO_secmat): Stainless steel; BimObjectMainCategory (BO_bomaincat): Kitchen; BimObjectMainCategoryCode (BO_bomaincat_code): kitchen; BimObjectCategory (BO_bocat): Furniture; BimObjectCategoryCode (BO_bocat_code): kitchen-furniture; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
